# IAR project efr32.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFR32BG1B232F256GM48 SiliconLaboratories EFR32BG1B232F256GM48
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: GENERATION_DONE; EFR32BG1B232F256GM48
  ICCARM.CCDiagSuppress: pa050
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: /home/miceuz/Downloads/SimplicityStudio_v4/developer/stacks/ble/v2.0.0.0\protocol\bluetooth_2.0\ble_stack\inc\common; /home/miceuz/Downloads/SimplicityStudio_v4/developer/stacks/ble/v2.0.0.0\protocol\bluetooth_2.0\ble_stack\inc\soc; inc; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\CMSIS\Include; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\Device\SiliconLabs\EFR32BG1B\Include; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\emdrv\config; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\emdrv\common\inc; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\emdrv\capsense\inc; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\emdrv\dmadrv\inc; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\emdrv\gpiointerrupt\inc; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\emdrv\nvm\inc; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\emdrv\rtcdrv\inc; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\emdrv\sleep\inc; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\emdrv\spidrv\inc; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\emdrv\tempdrv\inc; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\emdrv\uartdrv\inc; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\emdrv\ustimer\inc; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\emlib\inc; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\hardware\kit\EFR32BG1_BRD4300A\config; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\hardware\kit\common\bsp; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\hardware\kit\common\drivers; ..\..\..\Downloads\SimplicityStudio_v4\developer\stacks\ble\v2.0.0.0\platform\radio\rail_lib_1.3\chip\efr32\rf\common\cortex
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: soc-thermometer_2.bin
  ILINK.IlinkOutputFile: soc-thermometer_2.out
  ILINK.IlinkIcfFile: /home/miceuz/Downloads/SimplicityStudio_v4/developer/stacks/ble/v2.0.0.0\protocol\bluetooth_2.0\ble_stack\linker\bleDemo.icf
  ILINK.IlinkExtraOptions: --keep __iar_program_start; --no_range_reservations
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  General.FPU2: 0
  group (top)
    ../../../Downloads/SimplicityStudio_v4/developer/stacks/ble/v2.0.0.0/hardware/kit/common/bsp/: bsp_bcc.c bsp_stk.c bsp_stk_leds.c
    ../../../Downloads/SimplicityStudio_v4/developer/stacks/ble/v2.0.0.0/hardware/kit/common/drivers/: i2cspm.c si7013.c tempsens.c udelay.c
    ../../../Downloads/SimplicityStudio_v4/developer/stacks/ble/v2.0.0.0/platform/Device/SiliconLabs/EFR32BG1B/Source/IAR/: startup_efr32bg1b.c
    ../../../Downloads/SimplicityStudio_v4/developer/stacks/ble/v2.0.0.0/platform/emlib/src/: em_gpio.c em_i2c.c em_rtcc.c em_usart.c
    ./: main.c
    src/: InitDevice.c
  group gattdb
    ./: gatt_db.bgproj
  group include
    /home/miceuz/Downloads/SimplicityStudio_v4/developer/stacks/ble/v2.0.0.0/protocol/bluetooth_2.0/ble_stack/inc/common/: bg_errorcodes.h bg_gattdb_def.h bg_types.h gecko_configuration.h
    /home/miceuz/Downloads/SimplicityStudio_v4/developer/stacks/ble/v2.0.0.0/protocol/bluetooth_2.0/ble_stack/inc/soc/: native_gecko.h
  group lib
    /home/miceuz/Downloads/SimplicityStudio_v4/developer/stacks/ble/v2.0.0.0/protocol/bluetooth_2.0/lib/: binbootloader.o stack.a binstack.o
